<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\lcp_flight_software.ewp</path>
    </project>
    <batchBuild />
</workspace>
