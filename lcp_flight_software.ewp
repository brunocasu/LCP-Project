# IAR project lcp_flight_software.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 1024
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  OBJCOPY.OOCOutputFile: templproj.srec
  ILINK.IlinkOutputFile: lcp_flight_software.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core S3 - Unspecified
  General.GenStackSize: 128
  ICCRL78.CCDefines: NDEBUG
  group (top)
    src/: lcp_ax25.c lcp_ax25.h lcp_fsm.c lcp_fsm.h lcp_radio_driver.c lcp_radio_driver.h main.c MyRL78.h
    src/r_driver/: r_cg_adc.c r_cg_adc.h r_cg_adc_user.c r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_intc.c r_cg_intc.h r_cg_intc_user.c r_cg_macrodriver.h r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_serial.c r_cg_serial.h r_cg_serial_user.c r_cg_timer.c r_cg_timer.h r_cg_timer_user.c r_cg_userdefine.h r_systeminit.c
